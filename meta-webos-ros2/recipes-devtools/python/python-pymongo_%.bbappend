# for meta-ros/recipes-ros/rosbridge-suite/rosbridge-library_0.7.16.bb
PROVIDES += "${PYTHON_PN}-bson"
