# Remove the components blacklisted in webOS
RDEPENDS_${PN}_remove = "\
    yocs-localization-manager \
"
