# Remove the components blacklisted in webOS
RDEPENDS_${PN}_remove = "\
    velodyne-driver \
    velodyne-msgs \
    velodyne-pointcloud \
    ar-track-alvar \
"
