# Copyright (c) 2019 LG Electronics, Inc.

EXTENDPRAUTO_append = "webosupdater1"

RPROVIDES_${PN}_sota += "/bin/bash"
