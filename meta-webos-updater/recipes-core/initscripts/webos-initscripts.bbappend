# Copyright (c) 2019 LG Electronics, Inc.

EXTENDPRAUTO:append = "webosupdater1"

inherit usrmerge_fix
