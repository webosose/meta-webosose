# Copyright (c) 2019 LG Electronics, Inc.

EXTRA_OECONF_append = " --disable-qt"
