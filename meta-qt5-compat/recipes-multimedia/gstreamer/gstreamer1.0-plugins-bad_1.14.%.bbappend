# Copyright (c) 2019 LG Electronics, Inc.

EXTRA_OECONF_remove = "--disable-qt"
