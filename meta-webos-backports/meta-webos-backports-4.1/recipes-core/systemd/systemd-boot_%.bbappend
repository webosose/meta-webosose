# Fixes:
# http://gecko.lge.com:8000/Errors/Details/1001471
# TOPDIR/BUILD/work/qemux86_64-webos-linux/systemd-boot/250.5-r0/recipe-sysroot-native/usr/bin/x86_64-webos-linux/x86_64-webos-linux-gcc -m64 -march=core2 -mtune=core2 -msse3 -fstack-protector-all -O2 -D_FORTIFY_SOURCE=2 -Wformat -Wformat-security -Werror=format-security -Werror=return-type --sysroot=TOPDIR/BUILD/work/qemux86_64-webos-linux/systemd-boot/250.5-r0/recipe-sysroot -c ../git/src/boot/efi/stub.c -o src/boot/efi/stub.c.o -Wno-format-signedness -Wno-missing-field-initializers -Wno-unused-parameter -Wdate-time -Wendif-labels -Werror=format=2 -Werror=implicit-function-declaration -Werror=incompatible-pointer-types -Werror=int-conversion -Werror=overflow -Werror=override-init -Werror=return-type -Werror=shift-count-overflow -Werror=shift-overflow=2 -Werror=undef -Wfloat-equal -Wimplicit-fallthrough=5 -Winit-self -Wlogical-op -Wmissing-include-dirs -Wmissing-noreturn -Wnested-externs -Wold-style-definition -Wpointer-arith -Wredundant-decls -Wshadow -Wstrict-aliasing=2 -Wstrict-prototypes -Wsuggest-attribute=noreturn -Wunused-function -Wwrite-strings -Wno-maybe-uninitialized -Wno-unused-result -fno-stack-protector -fno-strict-aliasing -fpic -fwide-exec-charset=UCS2 -Wall -Wextra -Wsign-compare -nostdlib -std=gnu99 -ffreestanding -fshort-wchar -fvisibility=hidden -isystem TOPDIR/BUILD/work/qemux86_64-webos-linux/systemd-boot/250.5-r0/recipe-sysroot/usr/include/efi -isystem TOPDIR/BUILD/work/qemux86_64-webos-linux/systemd-boot/250.5-r0/recipe-sysroot/usr/include/efi/x86_64 -I TOPDIR/BUILD/work/qemux86_64-webos-linux/systemd-boot/250.5-r0/git/src/fundamental -DSD_BOOT -DGNU_EFI_USE_MS_ABI -include src/boot/efi/efi_config.h -include version.h -mno-red-zone -mno-sse -mno-mmx -Oplain -O2 -g
# cc1: error: argument to '-O' should be a non-negative integer, 'g', 's' or 'fast'
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-meson-Fix-build-with-optimization-plain.patch"
