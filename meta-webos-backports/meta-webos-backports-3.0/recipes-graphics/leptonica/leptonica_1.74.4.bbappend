# backport fix from meta-oe commit:
# 2914b30b02 leptonica: fix SRC_URI

SRC_URI = "http://www.leptonica.org/source/leptonica-${PV}.tar.gz"
