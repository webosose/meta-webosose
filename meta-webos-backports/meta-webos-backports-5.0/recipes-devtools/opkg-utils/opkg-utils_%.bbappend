# Copyright (c) 2024-2025 LG Electronics, Inc.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-opkg-make-index-set-f-by-default.patch"
