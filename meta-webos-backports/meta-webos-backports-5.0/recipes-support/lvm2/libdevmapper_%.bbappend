# Copyright (c) 2024 LG Electronics, Inc.

# kirkstone https://lists.openembedded.org/g/openembedded-devel/message/112340
# scarthgap https://lists.openembedded.org/g/openembedded-devel/message/112496
inherit nopackages
