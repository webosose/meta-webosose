# Copyright (c) 2023-2024 LG Electronics, Inc.

# Backport
# https://git.openembedded.org/openembedded-core/commit/?id=369fee186d6916322b9be9d936b654d0c5910cb3

SRC_URI = "git://github.com/intel/${BPN};branch=main;protocol=https"
