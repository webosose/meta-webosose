# backported from meta-oe 06eb9d658e71b6a61f2589d9618ae2ca35eaaf8b
BBCLASSEXTEND = "native"
