# Copyright (c) 2020 LG Electronics, Inc.

# backport fix from oe-core commit:
# cabaf5654d iso-codes: switch upstream branch master -> main

SRC_URI = "git://salsa.debian.org/iso-codes-team/iso-codes.git;protocol=http;branch=main;"
