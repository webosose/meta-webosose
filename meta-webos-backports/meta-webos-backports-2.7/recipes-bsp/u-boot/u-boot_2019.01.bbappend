# Backported from meta-raspberrypi:
# 2215d00 u-boot-fw-utils: apply the same rpi4 patches as for u-boot recipe

require u-boot-rpi4-${PV}.inc
