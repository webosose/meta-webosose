# Copyright (c) 2022-2023 LG Electronics, Inc.

require solana.inc

CARGO_SRC_DIR = "cli"
SUMMARY = "Solana CLI Tool suites"
HOMEPAGE = "https://github.com/solana-labs/solana"
