# Copyright (c) 2015-2020 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos1"

PACKAGECONFIG[selinux] = "--with-selinux,--without-selinux,libselinux"
