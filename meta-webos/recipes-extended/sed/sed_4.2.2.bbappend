# Copyright (c) 2015 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos1"

PACKAGECONFIG[selinux] = "--with-selinux,--without-selinux,libselinux"
