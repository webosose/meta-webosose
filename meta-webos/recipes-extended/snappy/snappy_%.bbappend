# Copyright (c) 2015-2023 LG Electronics, Inc.

EXTENDPRAUTO = "webos1"

BBCLASSEXTEND = "native"
