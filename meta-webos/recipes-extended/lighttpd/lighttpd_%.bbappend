# Copyright (c) 2019 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos1"

# PLAT-76698: Do not start the service at boot by default
SYSTEMD_AUTO_ENABLE = "disable"
