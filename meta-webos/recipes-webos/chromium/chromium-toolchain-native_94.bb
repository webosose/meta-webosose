# Copyright (c) 2023 LG Electronics, Inc.

PR = "r0"

require chromium-toolchain-native.inc

require webruntime-repo_94.inc

CLANG_VERSION = "14.0.0"
