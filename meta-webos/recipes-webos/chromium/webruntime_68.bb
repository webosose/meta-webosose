# Copyright (c) 2018-2019 LG Electronics, Inc.

require webruntime.inc

PR = "${INC_PR}.1"

PROVIDES = "virtual/webruntime"

WEBOS_VERSION = "68.0.3440.106-73_45c3d963f2c6c93dd70d34be635b8f840165989b"
WEBOS_REPO_NAME = "chromium68"

WEBOS_REPO_NAME_V8 = "v8"
WEBOS_VERSION_V8 = "6.8.275.26-11_f9c8b32c039775f49581907d1a1edac191a8119d"
SRCREV_v8 = "a14b9160368813b7ebe146b2612a8fce7b403ac7"
