# Copyright (c) 2022 LG Electronics, Inc.

SUMMARY = "Background Media Test Application"
AUTHOR = "Kalaiselvi P <kalaiselvi.p@lge.com>"

require webos-open-test-apps.inc

PR = "${INC_PR}.0"
