# Copyright (c) 2016-2019 LG Electronics, Inc.

require webos-open-test-apps.inc
PR = "${INC_PR}.1"

SUMMARY = "Bare (no-enyo) test application"
AUTHOR = "Anish TD <anish.td@lge.com>"
