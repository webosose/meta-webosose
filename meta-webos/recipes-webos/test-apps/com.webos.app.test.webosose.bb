# Copyright (c) 2018-2019 LG Electronics, Inc.

require webos-open-test-apps.inc
PR = "${INC_PR}.1"

SUMMARY = "webOS OSE test application"
AUTHOR = "Anish TD <anish.td@lge.com>"
