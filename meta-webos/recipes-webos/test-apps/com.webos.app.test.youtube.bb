# Copyright (c) 2016-2018 LG Electronics, Inc.

require webos-open-test-apps.inc
PR = "${INC_PR}.2"

WEBOS_PREFERRED_GFX_IMAGE_FORMAT_ENABLED = "0"

SUMMARY = "YouTube Test Application"
AUTHOR = "Bob Moragues <bob.moragues@lge.com>"
