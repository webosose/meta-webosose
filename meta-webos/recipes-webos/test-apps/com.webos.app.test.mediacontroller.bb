# Copyright (c) 2024-2025 LG Electronics, Inc.

SUMMARY = "MediaController Test Application"
AUTHOR = "Sushant Narayan <sushant16.narayan@lge.com>"

require webos-open-test-apps.inc

PR = "${INC_PR}.0"
