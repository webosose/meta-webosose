# Copyright (c) 2020-2022 LG Electronics, Inc.

require webos-open-test-apps.inc

PR = "${INC_PR}.0"

SUMMARY = "WebRTC"
AUTHOR = "Pankaj Kumar Maharana <pankaj.maharana@lge.com>"

