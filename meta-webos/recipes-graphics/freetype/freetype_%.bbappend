# Copyright (c) 2015-2020 LG Electronics, Inc.
AUTHOR = "Valery Volgutov <valery.volgutov@lge.com>"
EXTENDPRAUTO_append = "webos1"

PACKAGECONFIG_append = " pixmap"
