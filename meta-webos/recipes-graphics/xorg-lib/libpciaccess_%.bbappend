# Copyright (c) 2018 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos2"

BBCLASSEXTEND = "native nativesdk"
