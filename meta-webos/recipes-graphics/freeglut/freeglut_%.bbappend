# see
# https://lists.openembedded.org/g/openembedded-devel/message/101871

# depends on libxi
REQUIRED_DISTRO_FEATURES = "x11 opengl"
