# Copyright (c) 2022 LG Electronics, Inc.

# workaround for the upstream branch name change from master to main.
# inherit line below can be removed when the request is applied upstream.
# : https://lists.openembedded.org/g/openembedded-devel/message/97507
# : https://lists.openembedded.org/g/openembedded-devel/message/97508
inherit fix_branch_name
