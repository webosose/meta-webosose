# Copyright (c) 2021-2022 LG Electronics, Inc.

inherit qt6-cmake
inherit webos_cmake

EXTRA_OECMAKE += "-DCMAKE_CXX_STANDARD=17"
