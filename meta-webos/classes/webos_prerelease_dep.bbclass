# Copyright (c) 2013-2019 LG Electronics, Inc.
#
# webos_prerelease_dep
#
# This class is to be inherited by the recipe for every component that depends
# on WEBOS_DISTRO_PRERELEASE value at build time.
#

WEBOS_DISTRO_PRERELEASE ?= "devel"
