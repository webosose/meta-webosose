# Copyright (c) 2015-2016 LG Electronics, Inc.
#
# webos_machine_actual_dep
#
# This class is to be inherited by the recipe for every component that depends
# on the actual machine value.
#

inherit webos_machine_dep
