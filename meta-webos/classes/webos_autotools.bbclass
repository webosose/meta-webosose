# Copyright (c) 2012-2013 LG Electronics, Inc.
#
# webos_autotools
#
# This class is to be inherited by the recipe for every component that uses
# autotools for configuration.
#

inherit autotools

