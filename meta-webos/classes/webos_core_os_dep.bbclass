# Copyright (c) 2012-2013 LG Electronics, Inc.
#
# webos_core_os_dep
#
# This class is to be inherited by the recipe for every component is dependent
# on the core OS at build time.
#

