# Copyright (c) 2023 LG Electronics, Inc.

IMAGE_PR_SUFFIX = "${_pr_suffix}"

# Increse when features are changed
_pr_suffix = "coreboot1"

# Additional image features
