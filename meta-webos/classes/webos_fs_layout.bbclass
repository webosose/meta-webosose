# Copyright (c) 2012-2013 LG Electronics, Inc.
#
# webos_fs_layout
#
# This class alters the filesystem layout to be root under /opt/webos. It is
# intended that this only be inherited by webos_component, webos_upstream_from_repo,
# and webos_upstream_with_patches.
#

# XXX Not ready to activate this
#export base_prefix = "/opt/webos"
#export prefix = "/opt/webos/usr"
#export sysconfdir = "/opt/webos/etc"
#export localstatedir = "/opt/webos/var"
#export servicedir = "/opt/webos/srv"
