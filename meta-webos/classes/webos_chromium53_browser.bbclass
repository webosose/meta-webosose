# Copyright (c) 2016-2017 LG Electronics, Inc.

BROWSER_APPLICATION = "com.webos.app.browser"
BROWSER_APPLICATION_DIR = "${webos_applicationsdir}/${BROWSER_APPLICATION}"
