# Copyright (c) 2012-2018 LG Electronics, Inc.
#
# webos_public_repo
#
# This class is to be inherited by the recipe for every component that has (or
# will have) a public webOS OSE repo.
#

require conf/distro/include/webos-repositories.inc
