# Copyright (c) 2017-2025 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos1"

# we don't need xuser
USERADD_PARAM:${PN} = " "
