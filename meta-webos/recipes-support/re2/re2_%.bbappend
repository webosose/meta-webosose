# workaround for the upstream branch name change from master to main.
# inherit line below can be removed when the upstream kirkstone branch is updated.
# : https://lists.openembedded.org/g/openembedded-devel/message/99090
inherit fix_branch_name
