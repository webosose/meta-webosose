# Copyright (c) 2019 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos1"

EXTRA_OECONF += "--with-default-trust-store-file=/etc/ssl/certs/ca-certificates.crt \ "
