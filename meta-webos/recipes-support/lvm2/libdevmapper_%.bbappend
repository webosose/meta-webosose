# Copyright (c) 2020 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos1"

# thin-provisioning-tools is GPLv3
PACKAGECONFIG_remove = "thin-provisioning-tools"
