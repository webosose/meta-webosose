# Copyright (c) 2017-2025 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos1"

EXTRA_OECONF += "--disable-topology"
