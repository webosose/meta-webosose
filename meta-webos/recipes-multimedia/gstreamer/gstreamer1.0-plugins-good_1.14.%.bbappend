# Copyright (c) 2018 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos1"

PACKAGECONFIG_remove = "gtk"
