# Copyright (c) 2024 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos1"

PACKAGECONFIG:remove = "a52dec"
