# Copyright (c) 2022 LG Electronics, Inc.

require recipes-upstreamable/solana/solana.inc

S = "${WORKDIR}/git/keygen"
SUMMARY = "Solana Keygen Tool suites"
HOMEPAGE = "https://github.com/solana-labs/solana"