# Copyright (c) 2022 LG Electronics, Inc.

require recipes-upstreamable/solana/solana.inc

S = "${WORKDIR}/git/cli"
SUMMARY = "Solana CLI Tool suites"
HOMEPAGE = "https://github.com/solana-labs/solana"