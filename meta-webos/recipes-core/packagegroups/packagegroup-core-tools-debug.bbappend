# Copyright (c) 2013 LG Electronics, Inc.

# You don't need to change this value when you're changing just RDEPENDS_${PN} variable.
EXTENDPRAUTO_append = "webos1"

RDEPENDS_${PN} += "\
    ltrace \
    "
