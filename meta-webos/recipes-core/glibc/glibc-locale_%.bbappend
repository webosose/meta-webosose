# Copyright (c) 2018 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos1"

# until pseudo is completely fixed
# PLAT-48507 pseudo: random package_qa failures
# This issue seems to be triggered only in glibc-binary-localedata-* packages
INSANE_SKIP_glibc-binary-localedata-aa-dj += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-aa-dj.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-aa-er += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-aa-er+saaho += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-aa-et += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-af-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-af-za.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-agr-pe += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ak-gh += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-am-et += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-an-es += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-an-es.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-anp-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-ae += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-ae.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-bh += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-bh.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-dz += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-dz.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-eg += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-eg.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-iq += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-iq.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-jo += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-jo.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-kw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-kw.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-lb += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-lb.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-ly += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-ly.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-ma += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-ma.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-om += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-om.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-qa += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-qa.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-sa += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-sa.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-sd += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-sd.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-ss += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-sy += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-sy.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-tn += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-tn.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-ye += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ar-ye.iso-8859-6 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-as-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ast-es += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ast-es.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ayc-pe += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-az-az += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-az-ir += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-be-by += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-be-by.cp1251 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-be-by+latin += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bem-zm += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ber-dz += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ber-ma += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bg-bg += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bg-bg.cp1251 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bhb-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bho-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bi-vu += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bn-bd += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bn-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bo-cn += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bo-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-br-fr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-br-fr+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-br-fr.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-brx-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bs-ba += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-bs-ba.iso-8859-2 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-byn-er += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ca-ad += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ca-ad.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ca-es += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ca-es+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ca-es.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ca-fr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ca-fr.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ca-it += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ca-it.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ce-ru += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-chr-us += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-cmn-tw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-crh-ua += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-csb-pl += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-cs-cz += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-cs-cz.iso-8859-2 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-cv-ru += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-cy-gb += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-cy-gb.iso-8859-14 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-da-dk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-da-dk.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-at += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-at+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-at.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-be += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-be+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-be.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-ch += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-ch.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-de += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-de+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-de.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-it += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-it.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-li += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-lu += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-lu+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-de-lu.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-doi-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-dv-mv += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-dz-bt += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-el-cy += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-el-cy.iso-8859-7 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-el-gr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-el-gr+euro.iso-8859-7 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-el-gr.iso-8859-7 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-ag += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-au += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-au.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-bw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-bw.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-ca += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-ca.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-dk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-dk.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-gb += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-gb.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-hk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-hk.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-ie += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-ie+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-ie.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-il += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-ng += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-nz += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-nz.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-ph += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-ph.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-sg += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-sg.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-us += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-us.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-za.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-zm += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-zw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-en-zw.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-eo += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-ar += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-ar.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-bo += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-bo.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-cl += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-cl.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-co += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-co.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-cr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-cr.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-cu += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-do += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-do.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-ec += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-ec.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-es += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-es+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-es.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-gt += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-gt.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-hn += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-hn.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-mx += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-mx.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-ni += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-ni.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-pa += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-pa.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-pe += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-pe.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-pr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-pr.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-py += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-py.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-sv += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-sv.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-us += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-us.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-uy += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-uy.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-ve += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-es-ve.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-et-ee += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-et-ee.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-et-ee.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-eu-es += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-eu-es+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-eu-es.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fa-ir += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ff-sn += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fi-fi += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fi-fi+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fi-fi.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fil-ph += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fo-fo += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fo-fo.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-be += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-be+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-be.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-ca += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-ca.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-ch += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-ch.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-fr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-fr+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-fr.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-lu += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-lu+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fr-lu.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fur-it += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fy-de += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-fy-nl += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ga-ie += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ga-ie+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ga-ie.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gd-gb += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gd-gb.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gez-er += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gez-er+abegede += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gez-et += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gez-et+abegede += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gl-es += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gl-es+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gl-es.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gu-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gv-gb += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-gv-gb.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hak-tw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ha-ng += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-he-il += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-he-il.iso-8859-8 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hif-fj += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hi-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hne-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hr-hr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hr-hr.iso-8859-2 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hsb-de += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hsb-de.iso-8859-2 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ht-ht += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hu-hu += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hu-hu.iso-8859-2 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hy-am += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-hy-am.armscii-8 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ia-fr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-id-id += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-id-id.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ig-ng += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ik-ca += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-is-is += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-is-is.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-it-ch += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-it-ch.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-it-it += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-it-it+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-it-it.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-iu-ca += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ja-jp += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ja-jp.euc-jp += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ka-ge += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ka-ge.georgian-ps += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-kk-kz += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-kk-kz.pt154 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-kl-gl += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-kl-gl.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-km-kh += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-kn-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-kok-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ko-kr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ko-kr.euc-kr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ks-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ks-in+devanagari += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ku-tr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ku-tr.iso-8859-9 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-kw-gb += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-kw-gb.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ky-kg += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lb-lu += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lg-ug += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lg-ug.iso-8859-10 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-li-be += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lij-it += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-li-nl += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ln-cd += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lo-la += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lt-lt += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lt-lt.iso-8859-13 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lv-lv += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lv-lv.iso-8859-13 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-lzh-tw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mag-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mai-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mai-np += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mg-mg += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mg-mg.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mhr-ru += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mi-nz += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mi-nz.iso-8859-13 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mk-mk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mk-mk.iso-8859-5 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ml-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mni-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mn-mn += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mr-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ms-my += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ms-my.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mt-mt += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-mt-mt.iso-8859-3 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-my-mm += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nan-tw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nan-tw+latin += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nb-no += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nb-no.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nds-de += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nds-nl += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ne-np += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nhn-mx += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-niu-nu += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-niu-nz += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nl-aw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nl-be += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nl-be+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nl-be.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nl-nl += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nl-nl+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nl-nl.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nn-no += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nn-no.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nr-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-nso-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-oc-fr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-oc-fr.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-om-et += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-om-ke += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-om-ke.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-or-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-os-ru += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pa-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pap-aw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pap-cw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pa-pk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pl-pl += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pl-pl.iso-8859-2 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ps-af += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pt-br += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pt-br.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pt-pt += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pt-pt+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-pt-pt.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-quz-pe += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-raj-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ro-ro += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ro-ro.iso-8859-2 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ru-ru += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ru-ru.iso-8859-5 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ru-ru.koi8-r += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ru-ua += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ru-ua.koi8-u += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-rw-rw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sa-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sat-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sc-it += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sd-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sd-in+devanagari += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-se-no += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sgs-lt += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-shs-ca += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sid-et += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-si-lk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sk-sk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sk-sk.iso-8859-2 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sl-si += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sl-si.iso-8859-2 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sm-ws += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-so-dj += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-so-dj.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-so-et += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-so-ke += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-so-ke.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-so-so += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-so-so.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sq-al += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sq-al.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sq-mk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sr-me += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sr-rs += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sr-rs+latin += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ss-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-st-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-st-za.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sv-fi += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sv-fi+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sv-fi.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sv-se += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sv-se.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sw-ke += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-sw-tz += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-szl-pl += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ta-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ta-lk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tcy-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-te-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tg-tj += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tg-tj.koi8-t += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-the-np += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-th-th += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-th-th.tis-620 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ti-er += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ti-et += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tig-er += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tk-tm += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tl-ph += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tl-ph.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tn-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-to-to += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tpi-pg += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tr-cy += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tr-cy.iso-8859-9 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tr-tr += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tr-tr.iso-8859-9 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ts-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tt-ru += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-tt-ru+iqtelif += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ug-cn += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-uk-ua += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-uk-ua.koi8-u += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-unm-us += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ur-in += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ur-pk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-uz-uz += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-uz-uz+cyrillic += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-uz-uz.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-ve-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-vi-vn += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-wa-be += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-wa-be+euro.iso-8859-15 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-wa-be.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-wae-ch += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-wal-et += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-wo-sn += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-xh-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-xh-za.iso-8859-1 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-yi-us += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-yi-us.cp1255 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-yo-ng += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-yue-hk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-cn += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-cn.gb18030 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-cn.gb2312 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-cn.gbk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-hk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-hk.big5-hkscs += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-sg += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-sg.gb2312 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-sg.gbk += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-tw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-tw.big5 += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zh-tw.euc-tw += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zu-za += "host-user-contaminated"
INSANE_SKIP_glibc-binary-localedata-zu-za.iso-8859-1 += "host-user-contaminated"
