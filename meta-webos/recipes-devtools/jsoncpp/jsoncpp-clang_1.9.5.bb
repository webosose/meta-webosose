# Copyright (c) 2023-2024 LG Electronics, Inc.

require recipes-devtools/jsoncpp/jsoncpp_1.9.5.bb
require jsoncpp-clang.inc
