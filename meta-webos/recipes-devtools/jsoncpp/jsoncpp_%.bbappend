# Copyright (c) 2021-2025 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos1"

CXXFLAGS:append = " -DJSON_USE_EXCEPTION=0"
