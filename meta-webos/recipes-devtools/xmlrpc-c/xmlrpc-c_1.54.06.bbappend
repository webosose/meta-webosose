# Copyright (c) 2024-2025 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos2"

# Update SRCREV to revision which is in some branch, content is the same as original 00870af80021aa0a66cc72c9aeb00587cbfde560
# https://lists.openembedded.org/g/openembedded-devel/message/112906
SRCREV = "eff6cb488a644c1378318ff301392fb757fad2aa"
