# Copyright (c) 2024-2025 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos3"

# Update SRCREV to revision which is in some branch, content is the same as original 352aeaa9ae49e90e55187cbda839f2113df06278
# https://lists.openembedded.org/g/openembedded-devel/message/112906
SRCREV = "08b052692b70171a6fcb437d4f52a46977eda62e"
