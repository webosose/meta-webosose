# Copyright (c) 2024 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos1"

# Update SRCREV to revision which is in some branch, content is the same as original 86405c7e1bd4f70287204a28d242a1054daab520
# https://lists.openembedded.org/g/openembedded-devel/message/112906
SRCREV = "36b142d6179514989a44c1087f6c46182dafd21f"
