# Copyright (c) 2015-2025 LG Electronics, Inc.

EXTENDPRAUTO:append = "webos2"

DEPENDS:append = " binutils"
