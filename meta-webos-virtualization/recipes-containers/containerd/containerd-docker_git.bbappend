# Copyright (c) 2019 LG Electronics, Inc.

EXTENDPRAUTO_append = "webosvirt1"

RRECOMMENDS_${PN}_remove = "lxc"
