# Backport from:
# https://lists.yoctoproject.org/g/meta-virtualization/message/7977

REQUIRED_DISTRO_FEATURES = "systemd seccomp"
