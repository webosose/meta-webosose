# Copyright (c) 2019-2025 LG Electronics, Inc.

EXTENDPRAUTO:append = "webosvirt1"

RRECOMMENDS:${PN}:remove = "lxc"
