# Copyright (c) 2019-2024 LG Electronics, Inc.

EXTENDPRAUTO:append = "webosvirt1"

RRECOMMENDS:${PN}:remove = "lxc"
