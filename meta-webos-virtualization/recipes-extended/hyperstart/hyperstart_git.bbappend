# hyperstart/v0.2+gitAUTOINC+15bb718ad3-r0/recipe-sysroot/usr/include/bits/string_fortified.h:106:10: error: '__builtin_strncpy' output truncated before terminating nul copying as many bytes from a string as its length [-Werror=stringop-truncation]
CFLAGS += "-Wno-error=stringop-truncation"
