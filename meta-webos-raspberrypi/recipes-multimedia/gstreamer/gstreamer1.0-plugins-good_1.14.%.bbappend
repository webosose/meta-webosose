# Copyright (c) 2018-2019 LG Electronics, Inc.
require gstreamer1.0-webos-common.inc

EXTENDPRAUTO_append_rpi = "webosrpi1"

WEBOS_REPO_NAME_rpi = "gst-plugins-good"

WEBOS_VERSION_rpi = "1.14.4-2_9e2af695c462225d725c1b90494d08febbf33858"
