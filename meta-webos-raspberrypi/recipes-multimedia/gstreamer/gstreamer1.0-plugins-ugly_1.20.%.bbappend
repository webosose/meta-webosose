# Copyright (c) 2018-2023 LG Electronics, Inc.

EXTENDPRAUTO:append:rpi = "webosrpi1"

WEBOS_REPO_NAME:rpi = "gst-plugins-ugly"

WEBOS_VERSION:rpi = "1.14.4-2_bd628a6c45223639ca675da8963d7312c9d5d7f9"
