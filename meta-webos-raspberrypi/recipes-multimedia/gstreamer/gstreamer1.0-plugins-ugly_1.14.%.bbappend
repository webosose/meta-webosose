# Copyright (c) 2018 LG Electronics, Inc.

require gstreamer1.0-webos-common.inc

EXTENDPRAUTO_append_rpi = "webosrpi1"

WEBOS_REPO_NAME_rpi = "gst-plugins-ugly"

WEBOS_VERSION_rpi = "1.14.0-1_ab0b1ac1286ad19d957477b39082f28a5ed118fa"
