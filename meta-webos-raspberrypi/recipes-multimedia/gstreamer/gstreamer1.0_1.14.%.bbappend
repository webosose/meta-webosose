# Copyright (c) 2018 LG Electronics, Inc.

require gstreamer1.0-webos-common.inc

EXTENDPRAUTO_append_rpi = "webosrpi1"

WEBOS_REPO_NAME_rpi = "gstreamer"

WEBOS_VERSION_rpi = "1.14.0-1_a32596fec256608e20a987da750c995b55d72f14"
