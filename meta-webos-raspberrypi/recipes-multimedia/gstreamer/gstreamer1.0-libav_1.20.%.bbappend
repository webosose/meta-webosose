# Copyright (c) 2018-2024 LG Electronics, Inc.

EXTENDPRAUTO:append:rpi = "webosrpi1"

WEBOS_REPO_NAME:rpi = "gst-libav"
