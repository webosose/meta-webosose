# Copyright (c) 2017 LG Electronics, Inc.

EXTENDPRAUTO_append_rpi = "webosrpi1"

FFMPEG_CONF_append_rpi = " --enable-swresample"
