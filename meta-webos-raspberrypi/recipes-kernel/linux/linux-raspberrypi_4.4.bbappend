SRC_URI_append = " \
    file://0001-Remove-master-priviliges-for-drm-calls.patch \
    file://0002-Extend-drm-plane-properties.patch \
    file://0003-Fix-redundant-kernel-console-log-spew.patch \
    file://0004-Patch-permissions-issue-with-drm-clients.patch \
    file://0005-vc4-kms-Add-bcm2710-to-compatibility-list.patch \
    file://0006-miniuart-Add-bcm2709-and-bcm2710-to-compatibility.patch \
    file://0007-Fix-kernel-division-by-0-exception.patch \
    file://0008-Fix-scaling-and-fb-association-on-a-plane-asynchrono.patch \
    file://0009-Fix-scaling-not-working-for-specific-display-windows.patch \
    file://0010-Add-API-to-set-only-the-source-rectangle.patch \
    file://0011-Implement-page-flipping-changes-in-kernel.patch \
    file://0013-Fix-kernel-panic-on-10hr-YouTube-playback.patch \
    file://0014-DRM-custom-prop.patch \
    file://0015-DRM-forcing-permissions.patch \
    file://governor.cfg \
    file://ntfs.cfg \
    file://security.cfg \
    file://zram.cfg \
"
