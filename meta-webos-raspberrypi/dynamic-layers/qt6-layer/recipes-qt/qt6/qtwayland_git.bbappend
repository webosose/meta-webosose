# Copyright (c) 2021-2024 LG Electronics, Inc.

EXTENDPRAUTO:append:rpi = "webosrpi2"

PACKAGECONFIG:append:rpi = " dmabuf-client-buffer"
