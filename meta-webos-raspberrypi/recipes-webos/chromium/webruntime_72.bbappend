# Copyright (c) 2018-2020 LG Electronics, Inc.

EXTENDPRAUTO_append_rpi = "webosrpi1"

PACKAGECONFIG_remove_rpi = "gstreamer umediaserver neva-media gav"
