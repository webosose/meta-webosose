# Copyright (c) 2023-2025 LG Electronics, Inc.

require webruntime_rpi.inc
