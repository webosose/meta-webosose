# Copyright (c) 2022 LG Electronics, Inc.

EXTENDPRAUTO:append:rpi = "webosrpi1"

USE_ENCODER:rpi = "V4L2"

