# Copyright (c) 2024-2025 LG Electronics, Inc.

EXTENDPRAUTO:append:rpi = "webosrpi2"

PACKAGECONFIG:append:rpi= " gst-v4l2-encoder"
