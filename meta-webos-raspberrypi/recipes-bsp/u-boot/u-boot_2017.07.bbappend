# Copyright (c) 2017 LG Electronics, Inc.

EXTENDPRAUTO_append_rpi = "webosrpi1"

RDEPENDS_${PN}_append_rpi = " rpi-u-boot-scr u-boot-env"
