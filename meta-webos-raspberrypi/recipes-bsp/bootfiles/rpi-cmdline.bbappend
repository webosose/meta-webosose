# Copyright (c) 2023 LG Electronics, Inc.

EXTENDPRAUTO:append:rpi = "webosrpi1"

CMDLINE:append:rpi = " vt.global_cursor_default=0"
