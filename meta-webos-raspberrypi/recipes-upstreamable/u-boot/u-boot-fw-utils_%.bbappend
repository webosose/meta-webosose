# Copyright (c) 2019 LG Electronics, Inc.

include u-boot_rpi4.inc
