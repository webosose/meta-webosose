# Copyright (c) 2020 LG Electronics, Inc.

RDEPENDS:${PN}:remove = "qml-webos-framework-tools"
