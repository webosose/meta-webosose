# Copyright (c) 2020-2022 LG Electronics, Inc.

SRCREV = "${AUTOREV}"
SRC_URI = "git://github.com/namhyung/${BPN};branch=master;protocol=https"
